## boards/fate/esp32s3_fate_procpu_defconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0

CONFIG_UART_ESP32=y
CONFIG_SERIAL_ESP32_USB=y
CONFIG_CONSOLE=y
CONFIG_GPIO=y
CONFIG_CLOCK_CONTROL=y
```
