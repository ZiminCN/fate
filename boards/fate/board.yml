## boards/fate/board.yml
```yaml
board:
  name: esp32s3_fate
  full_name: ESP32-S3-Fate
  vendor: espressif
  socs:
  - name: esp32s3
```
